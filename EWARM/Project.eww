<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\08_H743ZI_Bootloader.ewp</path>
  </project>
  <batchBuild />
</workspace>
